<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L476_PA4_ADC1CH9_TEST.ewp</path>
  </project>
  <batchBuild />
</workspace>
